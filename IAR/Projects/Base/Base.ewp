# IAR project Base.ewp, settings and files
configuration Release (RL78)
  General.GenDeviceSelect: R5F100LG RL78 - R5F100LG
  General.GenCodeModel: 0
  General.GenDataModel: 0
  General.GenStackSize: 128
  General.GenNearHeapSize: 256
  General.GenFarHeapSize: 4096
  General.GenHugeHeapSize: 0
  ICCRL78.IccLang: 0
  ICCRL78.CCDefines: NDEBUG
  ICCRL78.CCIncludePath2: ..\..\Common\inc; ..\..\DDIL\inc; ..\Apps\inc; ..\Impl\inc; ProjectSupport\Config; ProjectSupport\IntProcess
  OBJCOPY.OOCOutputFile: Base.hex
  ILINK.IlinkOutputFile: Base.out
  ILINK.IlinkConfigDefines: __RESERVE_OCD_ROM=1; __RESERVE_OCD_TRACE_RAM=0; __RESERVE_HOTPLUGIN_RAM=0
  ILINK.IlinkIcfFile: ..\..\Common\link\lnkr5f100lg.icf
  ILINK.IlinkStackSize: 1
  ILINK.IlinkNearHeapSize: 1
  ILINK.IlinkFarHeapSize: 1
  ILINK.IlinkHugeHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Apps/inc
    ../Apps/inc/: main_inc.h
  group Apps/src
    ../Apps/src/: mainApp.c mainCallBackBeep.c mainCallBackLed.c
  group Common/inc
    ../../Common/inc/: ior5f100lg.h ior5f100lg_ext.h MacroDriver.h RL78G13_Clock.h RL78G13_OptionBytes.h RL78G13_Port.h
  group Common/Linker
    ../../Common/link/: lnkr5f100lg.icf
  group Common/src
    ../../Common/src/: RL78G13_Clock.c RL78G13_Port.c
  group DDIL/inc
    ../../DDIL/inc/: DDIL_ADC.h DDIL_Beep.h DDIL_BR24G02.h DDIL_BR25L040.h DDIL_Delay.h DDIL_DS18B20.h DDIL_ErrorCode.h DDIL_ExtKey.h DDIL_IR.h DDIL_LED.h DDIL_NixieTube.h DDIL_Uart.h
  group DDIL/src
    ../../DDIL/src/: DDIL_ADC.c DDIL_Beep.c DDIL_BR24G02.h DDIL_BR25L040.c DDIL_Delay.c DDIL_DS18B20.c DDIL_ExtKey.c DDIL_IR.c DDIL_LED.c DDIL_NixieTube.c DDIL_Uart.c
  group ProjectSupport/Impl/inc
    ../Impl/inc/: Delay.h Led.h SystemInit.h SystemUtil.h
  group ProjectSupport/Impl/src
    ../Impl/src/: Delay.c Led.c SystemInit.c SystemUtil.c
