# IAR project ProjectBase.ewp, settings and files
configuration Release (RL78)
  General.GenDeviceSelect: R5F100LG RL78 - R5F100LG
  General.GenCodeModel: 0
  General.GenDataModel: 0
  General.GenStackSize: 128
  General.GenNearHeapSize: 256
  General.GenFarHeapSize: 4096
  General.GenHugeHeapSize: 0
  ICCRL78.IccLang: 0
  ICCRL78.CCDefines: NDEBUG
  ICCRL78.CCIncludePath2: ..\..\..\Common; ..\..\..\DDIL\inc; ..\..\Apps; ..\..\DriverImpl\inc; ..\..\Functions\inc; ProjectSupport\Configs; ProjectSupport\IntProc
  OBJCOPY.OOCOutputFile: ProjectBase.hex
  ILINK.IlinkOutputFile: ProjectBase.out
  ILINK.IlinkIcfFile: ..\..\..\Common\lnkr5f100lg.icf
  ILINK.IlinkStackSize: 1
  ILINK.IlinkNearHeapSize: 1
  ILINK.IlinkFarHeapSize: 1
  ILINK.IlinkHugeHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Apps
    ../../Apps/: AppInc.h mainApp.c
  group Common
    ../../../Common/: lnkr5f100lg.icf
